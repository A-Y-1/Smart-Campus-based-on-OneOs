# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx, OS_TASK_SWITCH_NOTIFY, USE_HAL_DRIVER
  c include: .;application;..\..\arch\arm\armv7m\include;..\..\drivers\audio;board;board\CubeMX_Config\Inc;board\ports;board\packages;..\..\components\cJSON-v1.7.12;..\..\components\cli\include;..\..\common\include;..\..\components\diagnose\cpu_moniter;..\..\components\dlog\include;..\..\drivers;..\..\drivers\boot\cotex-m;..\..\drivers\bus;..\..\drivers\can;..\..\drivers\console;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\hwcrypto;.;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\mtd;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\sflash;..\..\drivers\spi;..\..\drivers\timer;..\..\drivers\watchdog;..\..\components\fs\include;..\..\components\fs\include\fatfs;..\..\drivers\graphic\font;..\..\drivers\graphic;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;..\..\drivers\hal\st\STM32L4xx_HAL\CMSIS\Include;..\..\drivers\infrared;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\net\molink\api\include;..\..\components\net\molink\core\include;..\..\components\net\molink\module\esp8266\include;..\..\components\net\molink\parser\include;..\..\components\net\molink\tools\include;..\..\components\mpu6xxx\inc;..\..\components\cloud\onenet\mqtt-kit\authorization;..\..\components\cloud\onenet\mqtt-kit\cert;..\..\components\cloud\onenet\mqtt-kit\mqtts_device;..\..\components\position;..\..\components\position\gnss_pos;..\..\components\position\gnss_pos\prot;..\..\components\position\gnss_pos\rcvr;..\..\components\position\gnss_pos\rtk;..\..\components\position\net_pos;..\..\components\net\protocols\mqtt\pahomqtt-v1.1.0\MQTTPacket\src;..\..\components\net\protocols\mqtt\pahomqtt-v1.1.0\MQTTClient-OneOS\src;..\..\drivers\sensors;..\..\components\shell\include;..\..\components\net\socket\include;..\..\components\net\socket\include\sys_socket;..\..\components\diagnose\stack_trace;..\..\drivers\usb\usb_device;..\..\drivers\usb\usb_device\Core\Inc
  asm define: OS_TASK_SWITCH_NOTIFY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    application/: main.c
    ./application/: sensor_on.c
    ../../demos/driver/: sensor_light_test.c
  group arch
    ../../arch/arm/armv7m/: arch_atomic.c arch_exception.c arch_interrupt.c arch_misc.c arch_task.c
    ../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
  group audio
    ../../drivers/audio/: audio_player.c audio_recorder.c es8388.c es8388_ll.c sai.c
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: bsp.c stm32l4xx_hal_msp.c stm32l4xx_it_bsp.c system_stm32l4xx.c
    board/startup/: startup_stm32l475xx_arm.s
  group cjson
    ../../components/cJSON-v1.7.12/: cJSON.c cJSON_Utils.c cJSON_port.c
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/backend/: console_backend.c
    ../../components/dlog/source/: dlog.c
  group drivers
    ../../drivers/block/: block_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/can/: can.c
    ../../drivers/timer/: clockevent.c clocksource.c clocksource_cortexm.c hrtimer.c timer.c
    ../../drivers/console/: console.c
    ../../drivers/: device.c driver.c plug.c
    ../../drivers/dma/: dma_ram.c soft_dma.c
    ../../drivers/fal/: fal.c fal_block.c fal_mtd.c fal_part.c
    ../../drivers/hwcrypto/: hw_crc.c hw_rng.c hwcrypto.c
    ../../drivers/i2c/: i2c.c soft_i2c_bus.c soft_i2c_bus_config.c
    ../../drivers/mtd/: mtd.c
    ../../drivers/pin/: pin.c
    ../../drivers/misc/: push_button.c pwm.c
    ../../drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_msd.c spi_tfcard.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/sflash/: sfbus.c sfdp.c sfdp_basic.c sflash.c sflash_info.c
    ../../drivers/boot/cotex-m/: vector_table.c
    ../../drivers/watchdog/: watchdog.c
  group filesystem
    ../../components/fs/source/fatfs/: diskio.c ff.c syscall.c unicode.c vfs_fatfs.c
    ../../components/fs/source/: fs_cmd.c vfs.c vfs_fd.c vfs_fs.c vfs_misc.c vfs_posix.c
  group font
    ../../drivers/graphic/font/: font_asc2_1608.c font_asc2_2412.c font_asc2_3216.c
  group graphic
    ../../drivers/graphic/: graphic.c st7789vw.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_can.c drv_common.c drv_crypto_crc.c drv_crypto_rng.c drv_gpio.c drv_hwtimer.c drv_iwdg.c drv_lptim.c drv_pwm.c drv_qspi.c drv_rtc.c drv_sai.c drv_spi.c drv_usart.c drv_usbd.c
    ../../drivers/hal/st/drivers/flash/: drv_flash_l4.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hcd.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_usb.c
  group infrared
    ../../drivers/infrared/: infrared.c remote_control_atk.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group molink
    ../../components/net/molink/parser/source/: at_parser.c at_printf.c at_resp.c
    ../../components/net/molink/module/esp8266/source/: esp8266.c esp8266_general.c esp8266_ifconfig.c esp8266_netconn.c esp8266_ping.c esp8266_wifi.c
    ../../components/net/molink/api/source/: mo_common.c mo_factory.c mo_general.c mo_ifconfig.c mo_netconn.c mo_ping.c mo_socket.c mo_wifi.c
    ../../components/net/molink/core/source/: mo_ipaddr.c mo_lib.c mo_object.c mo_time.c
    ../../components/net/molink/tools/source/: tool.c
  group mpu6xxx
    ../../components/mpu6xxx/src/: mpu6xxx.c sensor_inven_mpu6xxx.c
  group onenet
    ../../components/cloud/onenet/mqtt-kit/cert/: ca_certificate.c
    ../../components/cloud/onenet/mqtt-kit/authorization/: hmac_sha1.c onenet_base64.c token.c
    ../../components/cloud/onenet/mqtt-kit/mqtts_device/: onenet_device_sample.c onenet_mqtts.c
  group pahomqtt
    ../../components/net/protocols/mqtt/pahomqtt-v1.1.0/MQTTClient-OneOS/src/: MQTTClient.c MQTTOneOS.c
    ../../components/net/protocols/mqtt/pahomqtt-v1.1.0/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group sensors
    ../../drivers/sensors/: aht10.c ap3216c.c mpu6xxx_port.c sensor.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
  group socket
    ../../components/net/socket/source/: socket.c
  group usbd
    ../../drivers/usb/usb_device/Core/Src/: proto_usbd_core.c proto_usbd_ctlreq.c proto_usbd_ioreq.c
